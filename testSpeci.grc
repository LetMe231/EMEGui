options:
  parameters:
    author: yves.looser
    generate_options: qt_gui
    id: testSpeci
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1296e6
  states: {}
- name: delay
  id: variable
  parameters:
    value: round(2.3*samp_rate)
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '30'
  states: {}
- name: gain_tx
  id: variable
  parameters:
    value: '72'
  states: {}
- name: guard
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: length
  id: variable
  parameters:
    value: '2.304'
  states: {}
- name: nsamps
  id: variable
  parameters:
    value: '460800'
  states: {}
- name: rx_gain_var
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: t0
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: t_tx
  id: variable
  parameters:
    value: t0 + guard
  states: {}
- name: tone
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: tx_gain_var
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: N:\Empfang_data/rx_Versuch_1_CW.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: N:\Empfang_data/erste_Versuch_tx.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\yves.looser\OneDrive - OST\Dokumente\binforMorse.bin
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(nsamps+1200000)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '10000'
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '19500'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate/10
    type: complex
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 0.2e6
    center_freq0: center_freq
    clock_source0: external
    dev_addr: type=b200
    gain0: tx_gain_var
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 0.2e6
    center_freq0: uhd.tune_request(center_freq, samp_rate)
    clock_source0: external
    dev_addr: type=b200
    gain0: gain_rx
    samp_rate: samp_rate
    sd_spec0: A:B
    stream_args: peak=0.003906
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_1, '0']
- [blocks_delay_0, '0', uhd_usrp_sink_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_skiphead_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_1, '0']
- [blocks_head_0, '0', low_pass_filter_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_1, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_skiphead_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
